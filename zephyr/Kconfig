## zephyr/Kconfig
```kconfig
# SPDX-License-Identifier: Apache-2.0
# Copyright (c) 2022 Tan Li Boon

config LIBFAVONIUS
	bool "Favonius support library for writing C++ applications with Zephyr."
```
